# Keil uVision project STM3_MoBan.uvprojx, settings and files
target STM32工程模板 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_MoBan +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10x_HD
  c include: ..\APP;..\FWlib;..\FWlib\inc;..\FWlib\SRC;..\MALLOC;..\APP\AD;..\APP\BEEF;..\APP\Delay;..\APP\FLASH;..\APP\HMC5883;..\APP\i2c;..\APP\LED;..\APP\MPU_6050;..\APP\Usart;..\APP\XC_Config;..\APP\PWM;..\USMART;..\APP\DMP;..\APP\Moter;..\APP\Encoder;..\APP\Kalman;..\APP\BMP180;..\APP\BMP180;..\APP\SPI;..\APP\NRF24L01;..\APP\IMU;..\APP\modbus;..\CM3;..\APP\DIO;..\APP\74HC595;..\APP\Flash;..\APP\Relay;..\APP\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ../startup/: startup_stm32f10x_hd.s
  group USR
    ../user/: main.c stm32f10x_it.c
    ../APP/Flash/: flash.c
    ./: QueueByte.c
  group FWlib
    ../FWlib/SRC/: misc.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_dma.c
  group CMSYS
    ../CM3/: core_cm3.c system_stm32f10x.c
  group APP
    ../APP/XC_Config/: XC_Config.c
    ../APP/Delay/: delay.c
    ../APP/Usart/: usart.c
    ../APP/WDG/: wdg.c
  group MODBUS
    ../APP/modbus/: MODBUS.c MODBUS_CRC.c RESISTER.c MODBUS_HOST.c MyMap.c
  group STATEMENT
    ../statement/: XC_声明.txt
  group DIO
    ../APP/DIO/: DIO.c DIO.h
  group HC595
    ../APP/74HC595/: HC595.c HC595.h
  group RELAY
    ../APP/Relay/: relay.c
