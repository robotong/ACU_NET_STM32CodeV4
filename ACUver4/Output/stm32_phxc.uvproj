# Keil uVision project stm32_phxc.uvproj, settings and files
target STM32工程模板 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_MoBan +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\APP;..\FWlib;..\FWlib\inc;..\FWlib\SRC;..\MALLOC;..\APP\24C_XX;..\APP\AD;..\APP\BEEF;..\APP\Delay;..\APP\DS18B20;..\APP\FLASH;..\APP\HMC5883;..\APP\i2c;..\APP\infrared;..\APP\Interphase;..\APP\KEY;..\APP\LCD_FSMC;..\APP\LED;..\APP\MPU_6050;..\APP\RTC;..\APP\TOUCH;..\APP\Usart;..\APP\WDG;..\APP\XC_Config;..\APP\PWM;..\APP\SPI;..\APP\AD;..\statement;..\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ../startup/: startup_stm32f10x_hd.s
  group USR
    ../user/: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/SRC/: misc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_fsmc.c stm32f10x_usart.c
  group CMSYS
    ../CM3/: core_cm3.c system_stm32f10x.c
  group APP
    ../APP/XC_Config/: XC_Config.c
    ../APP/Interphase/: Interphase.c
    ../APP/LCD_FSMC/: lcd_FSMC.c
    ../APP/HMC5883/: HMC5883.c
    ../APP/DS18B20/: ds18b20.c
    ../APP/24C_XX/: 24C_XX.c
    ../APP/TOUCH/: touch.c
    ../APP/Delay/: delay.c
    ../APP/Usart/: usart.c
    ../APP/FLASH/: flash.c
    ../APP/RTC/: RTC.c
    ../APP/BEEF/: beef.c
    ../APP/WDG/: wdg.c
    ../APP/KEY/: key.c
    ../APP/LED/: led.c
    ../APP/i2c/: i2c.c
    ../APP/SPI/: spi.c
    ../APP/AD/: AD.c
    ../APP/PWM/: PWM.c
  group MALLOC
    ../MALLOC/: malloc.c
  group STATEMENT
    ../statement/: XC_声明.txt
